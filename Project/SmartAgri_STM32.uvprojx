# Keil uVision project SmartAgri_STM32.uvprojx, settings and files
target STM32F103C8 Flash (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(8000000) ELITTLE
  output: SmartAgri_STM32 +hex
  c flags: Optim=1 OneElfS=1
  c define: STM32F10X_MD
  c include: ..\User;..\Drivers;..\CMSIS;D:\Keil_v5\ARM\Pack\Keil\STM32F1xx_DFP\1.0.5\Device\Include;D:\Keil_v5\ARM\Pack\ARM\CMSIS\4.2.0\CMSIS\Include
  group CMSIS
    ../CMSIS/: startup_stm32f10x_md.s system_stm32f10x.c
  group User
    ../User/: main.c board.c system_tick.c app_control.c command_protocol.c lora_service.c wifi_service.c
  group Drivers
    ../Drivers/: actuators.c adc.c buzzer.c dht11.c esp_uart.c key.c oled.c serial2_printf.c sx1278.c
